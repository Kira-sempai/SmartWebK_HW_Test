# IAR project SWK_HardwareTest.ewp, settings and files
configuration SWK_HardwareTest (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205VG ST STM32F205VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F205xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: SWK_HardwareTest.out
  ILINK.IlinkIcfFile: stm32f205xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: 
  group Application/EWARM
    E:/development/SWK_HardwareTest//EWARM/: startup_stm32f205xx.s
  group Application/User
    ./: 
    ../Src/: stm32f2xx_it.c stm32f2xx_hal_msp.c main.c
  group Drivers
    ./: 
  group Drivers/STM32F2xx_HAL_Driver
    ./: 
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_tim_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_tim.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal.c stm32f2xx_hal_dma.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dac.c stm32f2xx_hal_pwr.c
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f2xx.c
